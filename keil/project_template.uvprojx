# Keil uVision project project_template.uvprojx, settings and files
target Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: fw_nano +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F407xx;USE_HAL_DRIVER
  c include: ..\profiles\f407ve\generated;..\vendor\rt-thread-nano\include;..\vendor\rt-thread-nano\libcpu\arm\cortex-m4;..\third_party\stm32f4\hal\Inc;..\third_party\stm32f4\device\Include;..\third_party\stm32f4\cmsis\Include;..\bsp\st\stm32f407;..\bsp\st\driver;..\board\stm32f407ve;..\framework\include;..\framework\components\protocol\include;..\framework\components\display\include;..\framework\app\include;..\framework\app\assets;..\framework\ports\rtthread\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\keil\stm32f407ve.sct
  group app
    ../app/: main.c
  group src/board/stm32f407ve
    ../board/stm32f407ve/: board.c board_devices.c board_console.c board_irq.c
  group src/bsp/st/driver
    ../bsp/st/driver/: drv_common.c drv_pin.c drv_serial.c drv_spi.c
  group src/bsp/st/stm32f407
    ../bsp/st/stm32f407/: stm32f407_map.c stm32f407_clock.c
  group src/framework/core
    ../framework/core/: device.c serial.c pin.c spi.c display.c clock.c ring.c status.c
  group src/framework/components
    ../framework/components/protocol/: protocol.c
    ../framework/components/display/: st7735s.c
  group src/framework/app
    ../framework/app/: demo_app.c
    ../framework/app/assets/: avatar_128x160.c
  group src/framework/ports/rtthread
    ../framework/ports/rtthread/: clock.c
  group src/vendor/rt-thread-nano
    ../vendor/rt-thread-nano/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../vendor/rt-thread-nano/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../vendor/rt-thread-nano/libcpu/arm/common/: div0.c
  group src/third_party/HAL
    ../third_party/stm32f4/hal/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group src/third_party/Device
    ../third_party/stm32f4/device/Source/Templates/: system_stm32f4xx.c
  group keil/startup
    ./: startup_stm32f407xx.s
