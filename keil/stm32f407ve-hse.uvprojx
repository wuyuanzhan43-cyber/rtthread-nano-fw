# Keil uVision project stm32f407ve-hse.uvprojx, settings and files
target Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: fw_v2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F407xx;USE_HAL_DRIVER
  c include: ..\profiles\f407ve-hse\generated;..\src\framework\include;..\src\app\include;..\src\platform\stm32f407;..\src\platform\board\stm32f407ve;..\src\vendor\rt-thread-nano\include;..\src\vendor\rt-thread-nano\libcpu\arm\cortex-m4;..\src\third_party\stm32f4\hal\Inc;..\src\third_party\stm32f4\device\Include;..\src\third_party\stm32f4\cmsis\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\keil\stm32f407ve-hse.sct
  group src/app
    ../src/app/: main.c
    ../src/app/task/: app_task.c
    ../src/app/rpc/: app_rpc.c
    ../src/app/boot/: app_boot.c
  group src/app/assets
    ../src/app/assets/: avatar_128x160.c
  group src/platform/board/stm32f407ve
    ../src/platform/board/stm32f407ve/: board.c
  group src/platform/stm32f407
    ../src/platform/stm32f407/: drv_common.c drv_dma.c drv_pin.c drv_serial.c drv_spi.c drv_i2c.c drv_adc.c drv_pwm.c stm32f407_map.c stm32f407_clock.c stm32f407_boot.c stm32f407_irq.c stm32f407_console.c stm32f407_fault.c stm32f407_iwdg.c stm32f407_nvm.c stm32f407_panic.c
  group src/framework/core
    ../src/framework/core/: fw_dev.c fw_serial.c fw_pin.c fw_spi.c fw_i2c.c fw_adc.c fw_pwm.c fw_display.c fw_clock.c fw_log.c fw_param.c fw_ring.c fw_status.c
  group src/framework/components
    ../src/framework/components/protocol/: fw_protocol.c
    ../src/framework/components/display/: st7735s.c
    ../src/framework/components/task/: fw_task.c
  group src/framework/port/rtthread
    ../src/framework/port/rtthread/: rtthread_clock.c rtthread_log.c rtthread_task.c
  group src/vendor/rt-thread-nano
    ../src/vendor/rt-thread-nano/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../src/vendor/rt-thread-nano/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../src/vendor/rt-thread-nano/libcpu/arm/common/: div0.c
  group src/third_party/HAL
    ../src/third_party/stm32f4/hal/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_iwdg.c
    ../src/third_party/stm32f4/device/Source/Templates/: system_stm32f4xx.c
  group keil/startup
    ./: startup_stm32f407xx.s
